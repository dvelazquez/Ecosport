File: Schematic/Schematic.sch (KiCad schematic (older format))
At the start: 33 parts

Commit message: first commit
Parts:
- gave numbers to parts that had none: 33
